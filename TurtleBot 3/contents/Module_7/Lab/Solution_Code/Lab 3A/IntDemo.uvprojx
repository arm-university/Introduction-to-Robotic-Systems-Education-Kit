# Keil uVision project IntDemo.uvprojx, settings and files
target Target 1 (6090000::V6.9::.\ARMCLANG)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: IntDemo
  c flags: Optim=2 v6Lang=3 v6LangP=1 wLevel=2
  c include: .\drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group drivers
    ./drivers/: gpio.c timer.c gpio.h platform.h timer.h
  group src
    ./src/: main.c leds.c leds.h
software components: CMSIS:CORE 5.1.1, Device:Startup 1.2.2
